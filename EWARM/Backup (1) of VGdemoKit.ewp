# IAR project Backup (1) of VGdemoKit.ewp, settings and files
configuration VGdemoKit (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; _USE_TCXO
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\BSP\radio\inc; ..\Tools\MALLOC; ..\Tools\LIST; ..\Tools\MULTI_TIMER; ..\Tools\flashDB; ..\Tools\flashDB\fal; ..\Tools\MAC; ..\Tools\Crypto; ..\Tools\ATcmd; ..\Tools\BLK
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VGdemoKit.hex
  ILINK.IlinkOutputFile: VGdemoKit.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: lora.c main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group BSP/Radio/Lora/inc
    ../BSP/radio/inc/: crc.h radio.h sx126x-board.h sx126x.h
  group BSP/Radio/Lora/src
    ../BSP/radio/src/: crc.c radio.c sx126x-board.c sx126x.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Tools
    ../Tools/LIST/: list.c
    ../Tools/MALLOC/: malloc.c
    ../Tools/MULTI_TIMER/: MultiTimer.c
  group Tools/AES
    ../Tools/Crypto/: lorawan_aes.c mac_aes.c
  group Tools/ATcmd
    ../Tools/ATcmd/: AT_Test.c ATcmd.c ATport.c
  group Tools/BLK
    ../Tools/BLK/: blink.c blink_test.c
  group Tools/flashDB
    ../Tools/flashDB/: fdb.c fdb_kvdb.c fdb_utils.c
  group Tools/flashDB/fal
    ../Tools/flashDB/fal/: fal.c fal_flash.c fal_flash_stm32f1_port.c fal_partition.c
  group Tools/MAC
    ../Tools/MAC/: mac.c mac_phy.c mac_port.c mac_test.c
